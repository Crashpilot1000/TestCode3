# Keil uVision project baseflight.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: baseflight +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: lib\CMSIS\CM3\CoreSupport;lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;lib\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./src/: cli.c config.c imu.c main.c mixer.c mw.c sensors.c serial.c board.h mw.h gps.c buzzer.c telemetry.c baseflight_mavlink.c navigation.c floppy.c baseflight_mavlink.h printf.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Drivers
    ./src/: drv_adc.c drv_adxl345.c drv_bmp085.c drv_hmc5883l.c drv_i2c.c drv_mpu3050.c drv_pwm.c drv_system.c drv_uart.c drv_ledring.c drv_mpu6050.c drv_mma845x.c drv_l3g4200d.c drv_ms5611.c drv_ledtoggle.c drv_i2c_lcd.c drv_gps.c drv_graupnersumh.c drv_spektrum.c drv_sonar.c drv_adxl345.h drv_pwm.h drv_system.h drv_gpio.c drv_gpio.h drv_mpu3050.h drv_l3g4200d.h drv_sonar.h
  group System
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_flash.c
    ./src/baseflight_startups/: startup_stm32f10x_md.s startup_stm32f10x_md_fy90q.s
    ./src/: printf.c
target STM32-Release (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: as above
  output: baseflight +hex
  c flags: Optim=4 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: CoOS\portable;CoOS\kernel;lib\CMSIS\CM3\CoreSupport;lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;lib\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32-FY90Q (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: baseflight_fy90q +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,FY90Q
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
